# Keil uVision project SmartBand.uvprojx, settings and files
target SmartBand (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SmartBand +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_HAL_DRIVER, STM32L431xx, HSE_VALUE=12000000, HSI_VALUE=16000000, __FPU_PRESENT=1, __FPU_USED=1
  c misc: --c99
  c include: ..\Core\Inc;..\App\Inc;..\HW_Drivers\Inc;..\Middleware\FreeRTOS\Inc;..\Middleware\FreeRTOS\Inc\portable;..\Middleware\Algorithm\Inc;..\Middleware\Protocol\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Core\Include;..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\Drivers\CMSIS\RTOS2\Include;..\Drivers\STM32L4xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329 --diag_suppress=L6330
  group Core
    ../Core/Src/: main.c stm32l4xx_it.c system_stm32l4xx.c
  group App
    ../App/Src/: app_manager.c task_heartrate.c task_bp.c task_impact.c task_alert.c task_stopwatch.c task_display.c task_sysmon.c
  group HW_Drivers
    ../HW_Drivers/Src/: hw_max30102.c hw_adxl345.c hw_oled_ssd1306.c hw_air780e.c hw_nrf24l01.c hw_vibrator.c
  group HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group CMSIS/Startup
    ../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l431xx.s
  group FreeRTOS/Kernel
    ../Middleware/FreeRTOS/Src/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c croutine.c heap_4.c cmsis_os2.c
    ../Middleware/FreeRTOS/Src/portable/: port.c
  group Algorithm
    ../Middleware/Algorithm/Src/: algo_heartrate.c algo_bp_estimation.c algo_impact_detect.c
  group Protocol
    ../Middleware/Protocol/Src/: proto_alert.c
